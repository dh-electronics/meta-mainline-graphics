SRC_URI = "git://git.ideasonboard.org/yavta.git"
SRCREV = "405e5307d823f02fcc683e87686eb22d0887ef91"
PR = "r3"
